options:
  parameters:
    author: cesar
    generate_options: qt_gui
    id: bb60_test
    output_language: python
    title: BB60-test
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '85'
    step: '0.1'
    stop: '110'
    value: '99.7'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: bb60_iq_0
  id: bb60_iq
  parameters:
    bandwidth: 27e6
    center: freq*1e6
    decimation: '2'
    purge: 'False'
    reflevel: '-30'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '6'
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 20e6
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [bb60_iq_0, '0', low_pass_filter_0, '0']
- [bb60_iq_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
