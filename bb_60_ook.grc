options:
  parameters:
    generate_options: qt_gui
    id: BB_60_ook
    output_language: python
    title: BB_60_ook
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: bb60_iq_0
  id: bb60_iq
  parameters:
    bandwidth: 27e6
    center: 1e9
    decimation: '1'
    purge: 'False'
    reflevel: '-30'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}

connections:
- [bb60_iq_0, '0', qtgui_freq_sink_x_0, '0']
- [bb60_iq_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
